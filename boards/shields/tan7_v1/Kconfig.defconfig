## boards/shields/tan7_v1/tan7_v1_defconfig
```kconfig
CONFIG_ZMK_KEYBOARD_NAME="TANZENT7"

CONFIG_ZMK_USB=y
CONFIG_ZMK_BLE=y

CONFIG_ZMK_KSCAN=y
```
